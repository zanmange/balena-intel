CONNECTIVITY_MODULES =+ " \
	rtl8812au \
"

CONNECTIVITY_MODULES_remove_surface-go = "rtl8812au"
